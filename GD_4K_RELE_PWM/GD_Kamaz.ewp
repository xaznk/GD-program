# IAR project GD_Kamaz.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: C:\GD\C++\GD_4K_rele_pwm\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x100
  General.SCCStackSize: 0x200
  General.SCRStackSize: 100
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.newCCIncludePaths: D:\AVR_PR\GD_Kamaz\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm640.xcl
  group (top)
    ./: RUN.C
  group RUN
    ./: ADC.H Command.h Declar.h GD.h interf_PC.h interr_Ex.h Kernel.h List_Command.h model_var.h RW_EEPROM.h Step_Motor.h Test.h TIMER.H UART.h
